# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\dfs;..\..\components\dfs\filesystems\romfs;..\..\components\dfs\include;..\..\components\drivers\include;..\..\components\drivers\usb\usbdevice;..\..\components\external\lua\applications;..\..\components\external\lua\exlibs;..\..\components\external\lua\lua;..\..\components\external\lua\test;..\..\components\finsh;..\..\components\init;..\..\components\libc\armlibc;..\..\components\rtgui\include;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\STM32_USB_Device_Library\Class\cdc\inc;Libraries\STM32_USB_Device_Library\Core\inc;Libraries\STM32_USB_HOST_Library\Core\inc;Libraries\STM32_USB_OTG_Driver\inc;USB\USB_DEV;USB\USB_DEV\USB_MSC;applications;drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c ui_init.c
  group Drivers
    drivers/: board.c ext_sram.c platform.c ra8875.c sdio_sd.c serial.c spi_flash_w25qxx.c stm32f20x_40x_spi.c stm32f4xx_it.c usart.c
  group gui_examples
    gui/: demo_application.c demo_view.c demo_xml.c demo_fnview.c demo_view_benchmark.c demo_view_dc.c demo_view_ttf.c demo_view_dc_buffer.c demo_view_animation.c demo_view_buffer_animation.c demo_view_instrument_panel.c demo_view_window.c demo_view_label.c demo_view_button.c demo_view_checkbox.c demo_view_progressbar.c demo_view_scrollbar.c demo_view_radiobox.c demo_view_textbox.c demo_view_listbox.c demo_view_menu.c demo_view_listctrl.c demo_view_combobox.c demo_view_slider.c demo_view_notebook.c demo_view_mywidget.c demo_view_box.c demo_view_edit.c demo_view_bmp.c demo_plot.c mywidget.c demo_view_digtube.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_DEV
    USB/USB_DEV/: stm32f4xx_dcd.c usb_bsp.c usbd_desc.c usbd_usr.c
    USB/USB_DEV/USB_MSC/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_storage_msd.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
  group lua
    ../../components/external/lua/applications/: lua_in_finsh.c
    ../../components/external/lua/exlibs/: lexamplelib.c
    ../../components/external/lua/lua/: lapi.c lauxlib.c lbaselib.c lcode.c ldblib.c ldebug.c ldo.c ldump.c legc.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lrotable.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c lundump.c lvm.c lzio.c
    ../../components/external/lua/test/: test.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../components/init/: components.c
  group libc
    ../../components/libc/armlibc/: mem_std.c stubs.c
  group RTGUI
    ../../components/rtgui/common/: asc12font.c asc16font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../components/rtgui/server/: driver.c mouse.c server.c topwin.c
    ../../components/rtgui/widgets/: box.c button.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c widget.c window.c
